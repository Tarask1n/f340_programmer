# Keil uVision project F340_bulk_bootloader.uvproj, settings and files
target Bootloader (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: F340_bulk_bootloader +hex
  c flags: Optimize=8 SizeSpeed=1
  group Code files
    ./: F3xx_Flash.c F3xx_USB0_Descriptor.c F3xx_USB0_InterruptServiceRoutine.c F3xx_USB0_Main.c F3xx_USB0_Standard_Requests.c F3xx_USB0_Vendor_Requests.c F340_USB0_Bulk.c STARTUP.A51 F3xx_XTEA.c
  group Header files
    ./: c8051f3xx.h C8051F340_defs.h compiler_defs.h F3xx_Flash.h F3xx_USB0_Bulk.h F3xx_USB0_Descriptor.h f3xx_usb0_interruptserviceroutine.h F3xx_USB0_Main.h F3xx_USB0_Register.h F3xx_USB0_Standard_Requests.h F3xx_USB0_Vendor_Requests.h F3xx_XTEA.h
